# Keil uVision project StartPointDSPANDRGB.uvprojx, settings and files
target S6E2CC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: S6E2CCAJ0A Cypress
  pack: Keil.FM4_DFP.1.4.0
  cpu: IRAM(0x1FFD0000,0x30000) IRAM2(0x20038000,0x10000) IROM(0x00000000,0x200000) IROM2(0x00406000,0xA000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DSP_AUDIO_PXL
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c include: .\RTE\Device\S6E2CCAJ0A;.\drivers;..\..\..\..\..\..\OneDrive - PXL\Hogeschool PXL\Onderwijs\2017-2018\SignaalAnalyse\PDL\2.1.0\drivers;..\..\..\..\..\..\OneDrive - PXL\Hogeschool PXL\Onderwijs\2017-2018\SignaalAnalyse\PDL\2.1.0\utilities;.\src
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x406000 size 0xa000
  memory RVCT9: RAM 0x1ffd0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
  group src
    ./src/: main.c pdl.c pdl_user.h gpio.h
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, Device:Startup 1.0.0
